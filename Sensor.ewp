# IAR project Sensor.ewp, settings and files
configuration Sensor (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ; FAT\; User\; Libraries\CMSIS\ST\STM32F4xx\Include; Libraries\CMSIS\Include; Libraries\STM32F4xx_StdPeriph_Driver\inc; Libraries\STM32_USB_OTG_Driver\inc; Libraries\STM32_USB_Device_Library\Class\cdc\inc; Libraries\STM32_USB_Device_Library\Core\inc; Utilities\STM32F4-Discovery
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fw.srec
  ILINK.IlinkOutputFile: STM32F4-Discovery_Sensor.out
  ILINK.IlinkIcfFile: stm32f40x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Reciever (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_USB_OTG_FS; RX
  OBJCOPY.OOCOutputFile: Sensor.hex
configuration Transciever (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: Sensor.hex
  group EWARM
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
    ./: system_stm32f4xx.c
  group FAT
    FAT/: diskio.c diskio.h fattime.c fattime.h ff.c ff.h ffconf.h integer.h
  group STM32F4_Discovery
    Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_rtc.h
  group User
    ./: fifo.h logic.c logic.h main.c main.h sd_operations.c sd_operations.h sdio_sd.c sdio_sd.h stm32f4xx_it.c
  group User/Periphery
    ./: acc.c acc.h battery.c battery.h rtc.c rtc.h tm_stm32f4_nrf24l01.c tm_stm32f4_nrf24l01.h tm_stm32f4_spi.c tm_stm32f4_spi.h usart.c usart.h
    Utilities/STM32F4-Discovery/: stm32f4_discovery_lis302dl.c stm32f4_discovery_lis302dl.h
